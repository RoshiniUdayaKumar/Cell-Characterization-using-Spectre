//Spice netlist for an NAND
simulator lang=spectre
subckt NAND2 (inputA inputB output VDD VSS)
        parameters wp=0.6u lp=0.2u wn=0.3u ln=0.3u
        M1 output inputA VDD VDD tsmc18P w=wp l=lp
        M2 output inputB VDD VDD tsmc18P w=wn l=ln
        M3 output inputA X VSS tsmc18N w=wp l=lp
        M4 X inputB VSS VSS tsmc18N w=wn l=ln
ends IV
